# Keil uVision project STM32-DEMO.uvproj, settings and files
target YetAnotherPilot (ARM-ADS)
  device: STM32F103T6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: yetanotherpilot +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: stm32\CMSIS;stm32\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group pilot
    ./: main.cpp
  group sensors
    ./sensors/: HMC5883.c MPU6050.c MS5611.c
  group common
    ./common/: adc.c I2C.c NRF24L01.c PPM.c printf.c sdio_sdcard.c timer.c vector.c
  group stm32
    ./: stm32f10x_it.c
    ./stm32/CMSIS/startup/: startup_stm32f10x_hd.s
    ./stm32/CMSIS/: core_cm3.c system_stm32f10x.c
    ./stm32/FWlib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c
