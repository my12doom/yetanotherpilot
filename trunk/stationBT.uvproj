# Keil uVision project stationBT.uvproj, settings and files
target YetAnotherPilotBluetooth (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bluetooth +hex
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,BLUETOOTH
  c include: stm32\CMSIS;stm32\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group common
    ./common/: NRF24L01.c printf.c timer.c vector.c eeprom.c MMC_SD.c
  group stm32
    ./: stm32f10x_it.c
    ./stm32/CMSIS/startup/: startup_stm32f10x_hd.s
    ./stm32/CMSIS/: core_cm3.c system_stm32f10x.c
    ./stm32/FWlib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_flash.c
  group bluetooth
    ./: bluetooth.cpp
  group fatffs
    ./fat/: ff.c sdcard.c diskioSPI.c
