# Keil uVision project station.uvproj, settings and files
target YetAnotherPilotStation (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: station +hex
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,STATION
  c include: stm32\CMSIS;stm32\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group common
    ./common/: NRF24L01.c printf.c timer.c vector.c
  group stm32
    ./: stm32f10x_it.c
    ./stm32/CMSIS/startup/: startup_stm32f10x_hd.s
    ./stm32/CMSIS/: core_cm3.c system_stm32f10x.c
    ./stm32/FWlib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
  group fat
    ./fat/: diskio.c ff.c sdcard.c
  group station
    ./: station.cpp
  group LCD
    ./LCD/: arc_lcd.c AsciiLib.c HzLib.c
