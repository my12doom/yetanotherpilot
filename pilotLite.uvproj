# Keil uVision project pilotLite.uvproj, settings and files
target YetAnotherPilotLite (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lite +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F1,LITE STM32F10X_MD
  c include: stm32\CMSIS;stm32\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group pilot
    ./: pilot.cpp
  group sensors
    ./sensors/: mag_offset.cpp HMC5883.c MPU6050.c MS5611.c
  group common
    ./common/: I2C.c PPM.c printf.c timer.c vector.c i2c_sw.c eeprom.c adc.c build.c param.cpp
  group stm32
    ./: stm32f10x_it.c
    ./stm32/CMSIS/startup/: startup_stm32f10x_hd.s
    ./stm32/CMSIS/: core_cm3.c system_stm32f10x.c
    ./stm32/FWlib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_flash.c
