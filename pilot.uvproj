# Keil uVision project pilot.uvproj, settings and files
target YetAnotherPilot (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: yetanotherpilot +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: stm32\CMSIS;stm32\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group pilot
    ./: pilot.cpp
  group sensors
    ./sensors/: HMC5883.c MPU6050.c MS5611.c BMP085.c mag_offset.cpp
    ./common/: ads1115.c
  group common
    ./common/: adc.c I2C.c NRF24L01.c PPM.c printf.c timer.c vector.c i2c_sw.c gps.c eeprom.c config.c
  group stm32
    ./: stm32f10x_it.c
    ./stm32/CMSIS/startup/: startup_stm32f10x_hd.s
    ./stm32/CMSIS/: core_cm3.c system_stm32f10x.c
    ./stm32/FWlib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_flash.c
  group nmea
    ./nmea/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group osd
    ./osd/: MAX7456.c
  group fatfs
    ./fat/: diskio.c ff.c sdcard.c
