# Keil uVision project pilot.uvprojx, settings and files
target YetAnotherPilot (ARM-ADS)
  device: STM32F103RF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0xC0000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: yetanotherpilot +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F1
  c misc: --diag_suppress 177,550,1
  c include: stm32\CMSIS;stm32\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group pilot
    ./: pilot.cpp ahrs.cpp
  group sensors
    ./sensors/: HMC5883.c MPU6050.c MS5611.c BMP085.c mag_offset.cpp sonar.c MPL3115A2.c adxrs453.c MPU9250.c adis16405.c
    ./common/: ads1115.c
    ./: pos_estimator.cpp
  group common
    ./common/: adc.c I2C.c NRF24L01.c PPM.c printf.c timer.c vector.c i2c_sw.c gps.c matrix.cpp param.cpp build.c ads1256.c space.cpp space.h spaceIO.cpp console.cpp
  group stm32
    ./: stm32f10x_it.c
    ./stm32/CMSIS/startup/: startup_stm32f10x_hd.s
    ./stm32/CMSIS/: core_cm3.c system_stm32f10x.c
    ./stm32/FWlib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_flash.c
  group nmea
    ./nmea/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group osd
    ./osd/: MAX7456.c
  group fatfs
    ./fat/: diskio.c ff.c sdcard.c
  group mass storage
    ./usb_mass_storage/: hw_config.c interupt.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_prop.c usb_pwr.c usb_scsi.c
  group usb_library
    ./usb_mass_storage/: usb_int.c usb_sil.c otgd_fs_int.c otgd_fs_pcd.c otgd_fs_dev.c otgd_fs_cal.c usb_regs.c usb_mem.c usb_istr.c usb_init.c usb_core.c
