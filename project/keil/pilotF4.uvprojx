# Keil uVision project pilotF4.uvprojx, settings and files
target pilotF4 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pilotF4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM324x9I_EVAL,STM32F4,USE_USB_OTG_FS,HSE_VALUE=8000000,__FPU_USED=1
  c misc: --diag_suppress 177,550,1 --gnu
  c include: ..\..\stm32\STM32F4xx_StdPeriph_Driver;.\..\;..\..\library
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group osd
    ../../osd/: MAX7456.c
  group main
    ../../main/: pilot.cpp
    ../../library/: ahrs.cpp ahrs.h pos_controll.cpp pos_controll.h pos_estimator.cpp pos_estimator.h data_interface.h data_protocol.cpp of_controller.cpp of_controller.h altitude_controller.cpp altitude_estimator.cpp motor_mixer.cpp ahrs2.cpp log.cpp altitude_estimatorCF.cpp
    ../../stm32/: stm32f4xx_it.c stm32f4xx_it.h
  group common
    ../../common/: adc.c ads1115.c ads1115_worker.c ads1256.c ads1258.c build.c gps.c I2C.c i2c_sw.c PPM.c printf.c timer.c uart4.c vector.c console.cpp matrix.cpp param.cpp space.cpp spaceIO.cpp NRF24L01.c
  group nmea
    ../../nmea/: context.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group sensors
    ../../sensors/: mag_offset.cpp px4flow.cpp adis16405.c adxrs453.c HMC5883.c hp203b.c MPU6050.c MPU9250.c MS5611.c sonar.c MS5611SPI.c HMC5983.c MPU9250SPI.c
  group file_system
    ../../fat/: diskioF4.c ff.c stm324xg_eval.c stm324xg_eval_sdio_sd.c
  group usb
    ../../usb_comF4/cdc/: usbd_cdc_core.c usbd_cdc_vcp.c
    ../../usb_comF4/core/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../usb_comF4/otg/: usb_core.c usb_dcd.c usb_dcd_int.c
    ../../usb_comF4/usb_conf/: usb_bsp.c usbd_desc.c usbd_usr.c
    ../../usb_comF4/: interrupt.c
  group stm32
    ../../stm32/: system_stm32f4xx.c system_stm32f4xx.h startup_stm32f40_41xxx.s
    ../../stm32/STM32F4xx_StdPeriph_Driver/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
target STM32F427_437xx (ARM-ADS)
  device: STM32F437II STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x8100000) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F427_437xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,USE_STM324x7I_EVAL,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100001
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
target STM32F40_41xxx (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F40_41xxx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
target STM32F401xx (ARM-ADS)
  device: STM32F401VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F401xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
