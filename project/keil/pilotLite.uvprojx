# Keil uVision project pilotLite.uvprojx, settings and files
target YetAnotherPilotLite (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lite +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F1,LITE
  c misc: --diag_suppress 177,550,1
  c include: stm32\CMSIS;stm32\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group pilot
    ./: pilot.cpp ahrs.cpp
  group sensors
    ./sensors/: mag_offset.cpp HMC5883.c MPU6050.c BMP085.c
  group common
    ./common/: I2C.c PPM.c printf.c timer.c vector.c i2c_sw.c adc.c build.c param.cpp space.cpp space.h spaceIO.cpp console.cpp
  group stm32
    ./: stm32f10x_it.c
    ./stm32/CMSIS/startup/: startup_stm32f10x_hd.s
    ./stm32/CMSIS/: core_cm3.c system_stm32f10x.c
    ./stm32/FWlib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_flash.c
  group usb_com
    ./usb_com/: hw_config.c interrupt.c otgd_fs_cal.c otgd_fs_cal.h otgd_fs_dev.c otgd_fs_dev.h otgd_fs_int.c otgd_fs_int.h otgd_fs_pcd.c otgd_fs_pcd.h otgd_fs_regs.h usb_conf.h usb_core.c usb_core.h usb_def.h usb_desc.c usb_desc.h usb_endp.c usb_init.c usb_init.h usb_int.c usb_int.h usb_istr.c usb_istr.h usb_lib.h usb_mem.c usb_mem.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
